# Keil uVision project usbd_vcp.uvproj, settings and files
target GD3210C-EVAL_USBD-VCP (ARM-ADS)
  device: GD32F105RG GigaDevice
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x08000000-0x080FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: USBD-VCP +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_CL,USE_USB_OTG_FS
  c include: ..\inc;..\..\..\..\Libraries\GD32F10x_StdPeriph_Driver\inc;..\..\..\..\Libraries\GD32_USB_OTG_Driver\inc;..\..\..\..\Libraries\GD32_USB_Device_Library\Core\inc;..\..\..\..\Libraries\GD32_USB_Device_Library\Class\cdc\inc;..\..\..\..\Utilities\GD32_EVAL\Common;..\..\..\..\Utilities\GD32_EVAL\GD3210C_EVAL;..\..\..\..\Libraries\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group App
    ../src/: app.c usbd_cdc_vcp.c usbd_desc.c usb_hwp.c usbd_user.c gd32f10x_it.c can_init.c periph.c
  group USB Driver
    ../../../../Libraries/GD32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB Device
    ../../../../Libraries/GD32_USB_Device_Library/Core/src/: usbd_core.c usbd_ctlx.c usbd_enum.c
  group USB Class
    ../../../../Libraries/GD32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group GD32_EVAL
    ../../../../Utilities/GD32_EVAL/Common/: lcd_log.c
  group GD32F10x
    ../../../../Libraries/CMSIS/: system_gd32f10x.c
    ../../../../Libraries/StartUp/: startup_gd32f10x_cl.s
  group GD32F10x_StdPeriph_Driver
    ../../../../Libraries/GD32F10x_StdPeriph_Driver/src/: gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_rcc.c gd32f10x_usart.c gd32f10x_timer.c gd32f10x_pwr.c gd32f10x_can.c
  group GD3210C_EVAL
    ../../../../Utilities/GD32_EVAL/GD3210C_EVAL/: gd3210c_eval.c gd3210c_eval_lcd.c
  group Doc
    ../: readme.txt
